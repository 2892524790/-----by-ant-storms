# Keil uVision project RoboMaster.uvprojx, settings and files
target RoboMaster (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoboMaster +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\CMSIS;..\user\FreeRTOS;..\user\FreeRTOS\include;..\user\FreeRTOS\portable;..\user\FreeRTOS\CMSIS_RTOS;..\user\FreeRTOS\portable\MemMang;..\user\FreeRTOS\portable\ARM_CM4F;..\user\main;..\user\user_lib\adrc;..\user\user_lib\algorithums;..\user\user_lib\kalmanfilter;..\user\user_lib\pid;..\user\user_lib\ramp;..\user\user_lib\user;..\FWLIB\inc;..\Project;..\user\DSP;..\user\DSP\Include;..\user\hardware\led;..\user\APP\start_task;..\user\APP\chassis_task;..\user\APP\can_receive;..\user\hardware\can;..\user\hardware\timer;..\user\hardware\spi;..\user\hardware\rc;..\user\APP\remote_control;..\user\mpu;..\user\hardware\delay;..\user\APP\gimbal_task;..\user\APP\heartbeat_task;..\user\APP\detect_task;..\user\hardware\sys;..\user\hardware\iic;..\user\hardware\usart;..\user\rmlib;..\user\APP\tx2_task;..\user\APP\shoot_task;..\user\user_lib\adrc;..\user\APP\ui_task;..\user\hardware\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../user/main/: main.c
    ../CMSIS/: stm32f4xx_it.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
  group RTOS
    ../user/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/ARM_CM4F/: port.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
  group hardware
    ../user/hardware/led/: led.c
    ../user/hardware/can/: can.c
    ../user/hardware/rc/: rc.c
    ../user/hardware/delay/: delay.c
    ../user/hardware/sys/: sys.c
    ../user/hardware/usart/: usart6.c usart1.c
    ../user/hardware/ADC/: adc.c
  group user_lib
    ../user/user_lib/user/: user_lib.c
    ../user/DSP/: arm_cortexM4lf_math.lib
    ../user/user_lib/pid/: pid.c
    ../user/user_lib/kalmanfilter/: kalman_filter.c kalman.c
    ../user/rmlib/: RM_Client_UI.c protocol.c judgement_info.c
  group mpu
    ../user/mpu/: accelerometer_calibration.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c MPU_SPI_Init.c MPU_TIME_Init.c BSP_Flash.c mpu_delay.c
  group APP
    ../user/APP/start_task/: start_task.c
    ../user/APP/chassis_task/: chassis_task.c
    ../user/APP/remote_control/: remote_control.c
    ../user/APP/shoot_task/: shoot_task.c
    ../user/APP/can_receive/: CAN_receive.c
    ../user/APP/detect_task/: detect_task.c
    ../user/APP/gimbal_task/: gimbal_task.c
    ../user/APP/tx2_task/: Tx2_task.c
    ../user/rmlib/: judge_task.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.5.0
